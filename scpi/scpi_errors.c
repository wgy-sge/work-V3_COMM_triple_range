/********************    ELoader  通讯板嵌入式程序    ********************
Copyright (C), 2010, Zidetech. Co., Ltd.
* File Name          : scpi_errors.c
* Author             : lu guangping
* Version            : V0.0.1
* Date               : 2010/9/15
* Description        : scpi用到的错误说明信息
*************************************************************************/

#include "scpi_errors.h"


//////////////////////////////////////////////////////////////////////////////////////////////////////////////////
//
//	-100 to -199 Command Errors
//	A command error indicates that the test set's GPIB parser has detected an IEEE 488.2 syntax error. 
//	When one of these errors is generated, the command error bit in the event status register is set.
//
//////////////////////////////////////////////////////////////////////////////////////////////////////////////////

const char too_many_errors[]= "Too many errors";

//100
const char Command_errors[][25]=
{
	"Command error",                       //100
	"Invalid character",
	"Syntax error",
	"Invalid separator",
	"Data type error",
	"GET not allowed",
	"Semicolon unwanted",
	"Comma unwanted",
	"Parameter not allowed",
	"Missing parameter",
};

//110
const char Command_header_errors[][30]=
{
	"Command header error",                  //110
	"Header separator error",
	"Program mnemonic too long",
	"Undefined header",
	"Header suffix out of range",
	"Command can not query",
	"Command must query",

};

//120
const char Numeric_data_errors[][30]=
{
	"Numeric data error",                    //120
	"Invalid character in number",
	"Exponent too large",
	"Too many digits",
	"Numeric data not allowed",
};

//130
const char Suffix_errors[][20]=             
{
	"Suffix error",                          //130
	"Invalid suffix",
	"Suffix too long",
	"Suffix not allowed",
};

//140
const char Character_data_errors[][30]=
{
	"Character data error",					 //140
	"Invalid character data",
	"Character data too long",
	"Character data not allowed",
};

//150
const char String_data_errors[][25]=
{
	"String data error",                     //150
	"Invalid string data",
	"String data not allowed",
};

//160
const char Block_data_errors[][25]=
{
	"Block data error",                      //160
	"Invalid block data",
	"Block data not allowed",

};


//170
const char Expression_errors1[][30]=
{
	"Expression error",                      //170
	"Invalid expression",
	"Expression data not allowed",
};


//180
const char Macro_errors1[][35]=
{
	"Macro error",                           //180
	"Invalid outside macro definition",
	"Invalid inside macro definition",
	"Macro parameter error",

};


//////////////////////////////////////////////////////////////////////////////////////////////////////////////////
//
//	-200 to -299 Execution Errors 
//	These errors are generated when something occurs that is incorrect in the current state of the instrument. 
//	These errors may be generated by a user action from either the remote or the manual user interface
//
//////////////////////////////////////////////////////////////////////////////////////////////////////////////////
//200
const char Execution_errors[][25]=
{
	"Execution error",                        //200
	"Invalid while in local",
	"Settings lost due to rtl",
	"Command protected",
	"Calibration failed",
	"Not sequence edit mode",
	"Not sequence test mode",
	"Not sequence mode",
	"Sequence running",
	"Sequence result clean",

};

//210
const char Trigger_errors[][20]=
{
	"Trigger error",                          //210
	"Trigger ignored",
	"Arm ignored",
	"Init ignored",
	"Trigger dead lock",
	"Arm dead lock",

};


//220
const char Parameter_errors[][25]=
{
	"Parameter error",                         //220
	"Setting conflict",
	"Data out of range",
	"Too much data",
	"Illegal paramter value",
	"Out of memory",
	"List not same length",
	"Password error",
	"File absent",
	"Sequence file absent",
	"Data corrupt or stale",
	"Data questionable",
	"Invalid format",
	"Invalid version",
	"Calibration code error",
};

//240
const char Hardware_errors[][18]=
{
	"Hardware error",                           //240
	"Hardware missing",
	"NO reference",
};


//250
const char Mass_storage_errors[][23]=
{
	"Mass storage error",                      //250
	"Missing mass storage",
	"Missing media",
	"Corrupt media",
	"Media full",
	"Directory full",
	"File name not found",
	"File name error",
	"Media protected",
	"Not selected fil",
};


//Expression errors
//261
const char Expression_errors2[][23]=
{
	"Math in expression",                       //261
}; 

//271
const char Macro_errors2[][32]=
{
	"Macro syntax error",                       //271
	"Macro execution error",
	"Illegal macro label",
	"Use placeholder improperly",
	"Macro definition too long",
	"Macro recursion",
	"Macro redefinition",
	"Macro header not found",
	"Macro cause command too long",
};

//280
const char Program_errors[][28]=
{
	"Program error",                           //280
	"Can not create program",
	"Illegal program name",
	"Illegal variable name",
	"Program currently running",
	"Program syntax error",
	"Program runtime error",
};


//290
const char Memory_use_errors[][32]=
{
	"Memory use error",				          //290
	"",
	"Referenced name not exist",
	"Referenced name already exist",
	"Incompatible type",
	"Input buffer overflow",
	"Out buffer overflow",
	
};

/*
//350
const char Query_Memory_errors[][32]=
{
	"Query overflow",	
};*/

//////////////////////////////////////////////////////////////////////////////////////////////////////////////////
//
//	-400 to -800 Query and System Errors 
//	A Query error is generated either when data in the instrument's GPIB output queue has been lost, 
//	or when an attempt is being made to read data from the output queue when no output is present or pending.
//
//////////////////////////////////////////////////////////////////////////////////////////////////////////////////
//400
const char Query_errors[][20]=
{
	"Query error",				//400
	"Query INTERRUPTED",        //410
	"Query UNTERMINATED",		//420
	"Query DEADLOCKED",			//430
	"Query UNTERMINATED",		//440
};

//30000
const char Fmodbus_extern_errors[][50]=
{
"Register address error",	
"SCPI remote lock",	
"Device type lost",	
"Temperature calibrate data lost",	
"Readback current range 1 calibrate data lost",	
"Readback current range 2 calibrate data lost",	
"Readback voltage range 1 calibrate data lost",	
"Readback voltage range 2 calibrate data lost",
"Constant current range 1 calibrate data lost",
"Constant current range 2 calibrate data lost",
"Constant voltage range 1 calibrate data lost",
"Constant voltage range 2 calibrate data lost",
"Constant power range 1 calibrate data lost",
"Constant power range 2 calibrate data lost",
"Constant resistance range 1 calibrate data lost",
"Constant resistance range 2 calibrate data lost",
"Constant resistance range 3 calibrate data lost",
"Constant resistance range 4 calibrate data lost",
"",
"Current step out of range",
"Read only register",

};


ERR_FLASH_INFO_T err_flash_info;//滚动显示错误信息用

void Panel_ReadError(short err_code)
{
	err_flash_info.err_busy= TRUE;
	err_flash_info.err_num= 1;
	err_flash_info.err_code= err_code;
	err_flash_info.flash_cyc= 300;
	err_flash_info.err_str_start= 0;
	err_flash_info.err_str_end= 0;

	if ((err_code< ERR_WRITE_ONLY_READ_REG+1)&&(err_code>= ERR_REG_ADDRESS_WRONG))
	{
		err_flash_info.p_err_str= Fmodbus_extern_errors[err_code- ERR_REG_ADDRESS_WRONG];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
		return;
	}

	err_code= -err_flash_info.err_code;
	if (err_code== ERROR_TOOMANY)
	{
		err_flash_info.p_err_str= too_many_errors;
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	} 
	else if ((err_code< COMMAND_HEADER_ERRORS)&&(err_code>= COMMAND_ERRORS))
	{
		err_flash_info.p_err_str= Command_errors[err_code- COMMAND_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	} 
	else if ((err_code< NUMERIC_DATA_ERRORS)&&(err_code>= COMMAND_HEADER_ERRORS))
	{
		err_flash_info.p_err_str= Command_header_errors[err_code- COMMAND_HEADER_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< SUFFIXERRORS)&&(err_code>= NUMERIC_DATA_ERRORS))
	{
		err_flash_info.p_err_str= Numeric_data_errors[err_code- NUMERIC_DATA_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< CHARACTER_DATA_ERRORS)&&(err_code>= SUFFIXERRORS))
	{
		err_flash_info.p_err_str= Suffix_errors[err_code- SUFFIXERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< STRING_DATA_ERRORS)&&(err_code>= CHARACTER_DATA_ERRORS))
	{
		err_flash_info.p_err_str= Character_data_errors[err_code- CHARACTER_DATA_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< BLOCK_DATA_ERRORS)&&(err_code>= STRING_DATA_ERRORS))
	{
		err_flash_info.p_err_str= String_data_errors[err_code- STRING_DATA_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< EXPRESSION_ERRORS1)&&(err_code>= BLOCK_DATA_ERRORS))
	{
		err_flash_info.p_err_str= Block_data_errors[err_code- BLOCK_DATA_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< MACRO_ERRORS1)&&(err_code>= EXPRESSION_ERRORS1))
	{
		err_flash_info.p_err_str= Expression_errors1[err_code- EXPRESSION_ERRORS1];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}

	//------------------------------------------------------------------------------------
	else if ((err_code< EXECUTION_ERRORS)&&(err_code>= MACRO_ERRORS1))
	{
		err_flash_info.p_err_str= Macro_errors1[err_code- MACRO_ERRORS1];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}

	else if ((err_code< TRIGGER_ERRORS)&&(err_code>= EXECUTION_ERRORS))
	{
		err_flash_info.p_err_str= Execution_errors[err_code- EXECUTION_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< PARAMETER_ERRORS)&&(err_code>= TRIGGER_ERRORS))
	{
		err_flash_info.p_err_str= Trigger_errors[err_code- TRIGGER_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< HARDWARE_ERRORS)&&(err_code>= PARAMETER_ERRORS))
	{
		err_flash_info.p_err_str= Parameter_errors[err_code- PARAMETER_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< MASS_STORAGE_ERRORS)&&(err_code>= HARDWARE_ERRORS))
	{
		err_flash_info.p_err_str= Hardware_errors[err_code- HARDWARE_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< EXPRESSION_ERRORS2)&&(err_code>= MASS_STORAGE_ERRORS))
	{
		err_flash_info.p_err_str= Mass_storage_errors[err_code- MASS_STORAGE_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< PROGRAM_ERRORS)&&(err_code>= MACRO_ERRORS2))
	{
		err_flash_info.p_err_str= Macro_errors2[err_code- MACRO_ERRORS2];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< MEMORY_USE_ERRORS)&&(err_code>= PROGRAM_ERRORS))
	{
		err_flash_info.p_err_str= Program_errors[err_code- PROGRAM_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if ((err_code< 300)&&(err_code>= MEMORY_USE_ERRORS))
	{
		err_flash_info.p_err_str= Memory_use_errors[err_code- MEMORY_USE_ERRORS];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	//---------------------------------------------------------------------------------
	else if (err_code== EXPRESSION_ERRORS2)
	{
		err_flash_info.p_err_str= Expression_errors2[0];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if (err_code== QUERY_ERRORS)
	{
		err_flash_info.p_err_str= Query_errors[0];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if (err_code== QUERY_ERRORS+10)
	{
		err_flash_info.p_err_str= Query_errors[1];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if (err_code== QUERY_ERRORS+20)
	{
		err_flash_info.p_err_str= Query_errors[2];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if (err_code== QUERY_ERRORS+30)
	{
		err_flash_info.p_err_str= Query_errors[3];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}
	else if (err_code== QUERY_ERRORS+40)
	{
		err_flash_info.p_err_str= Query_errors[4];
		err_flash_info.err_str_len= strlen(err_flash_info.p_err_str);
	}

}

/*
bool err_flash_procesor(void)
{
	s8 i, j;
	bool finish_flag= FALSE;

	err_flash_info.flash_cyc= 300;

	memset(err_flash_info.dispbuf, 0, sizeof(err_flash_info.dispbuf));

	if (err_flash_info.err_str_end== err_flash_info.err_str_len)
	{
		j=0;
		for (i= err_flash_info.err_str_start; i< err_flash_info.err_str_end; i++)
		{
			err_flash_info.dispbuf[j]=  err_flash_info.p_err_str[i];
			j++;
		}
		while (j< 12)//末尾部分补空
		{
			err_flash_info.dispbuf[j]= ' ';
			j++;
		}
	} 
	else
	{
		j= 12;
		for (i= err_flash_info.err_str_end; i>= err_flash_info.err_str_start; i--)
		{
			err_flash_info.dispbuf[j-1]=  err_flash_info.p_err_str[i];
			j--;
		}

		while (j)//刚开始显示前补空
		{
			err_flash_info.dispbuf[j-1]= ' ';
			j--;
		}	
	}

	if (err_flash_info.err_str_end< err_flash_info.err_str_len)
	{
		err_flash_info.err_str_end++;
		if (err_flash_info.err_str_end- err_flash_info.err_str_start> 11)//显示区满则窗口滑动
		{
			err_flash_info.err_str_start++;
		}
	}
	else if (err_flash_info.err_str_start< err_flash_info.err_str_len)//最后部分显示时后补空
	{
		err_flash_info.err_str_start++;
	}
	else//显示完成
	{
		err_flash_info.err_busy= FALSE;
		finish_flag= TRUE;
	}

	err_flash_info.dispbuf[12]= '\0';
	CapitalsChange(err_flash_info.dispbuf);
	VFD_Clear_All();
	display_string((u8*)err_flash_info.dispbuf, 0, 12);
	return finish_flag;
}*/