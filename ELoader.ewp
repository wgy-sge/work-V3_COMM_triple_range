# IAR project ELoader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; library\inc; scpi\; scpi\cmd; Fmodbus; w5500\; driver; canopen
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Load_com_V1_8008000.bin
  ILINK.IlinkOutputFile: ELoader.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: ELoader.bin
  group canopen
    CANopen/: can.c can.h canopenpoll.c canopenpoll.h mco.c mco.h mcohw.h mcohw_LPC2.c MCP2510.h user_LPC2.c
  group driver
    driver/: dma_uart1.c dma_uart1.h dma_uart3.c dma_uart3.h mb_config.h trpa_trsm.c trpa_trsm.h uvmb_lan.c uvmb_lan.h uvmb_rs232.c uvmb_rs232.h uvmb_rs485.c uvmb_rs485.h uvmb_tcp_lan.c uvmb_tcp_lan.h
  group Fmodbus
    Fmodbus/: fmb_client.c fmb_crc.c fmb_global.c fmb_rtu.c port_event.c port_serial.c port_timer.c
  group lib
    library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group scpi
    scpi/: IEEE488.2_Errors.h scpi_errors.c scpi_errors.h scpi_interface.h scpi_keyword_table.c scpi_macro.h scpi_parser.c scpi_parser.h scpi_processor.c scpi_processor.h scpi_variable.c
  group scpi/cmd
    scpi/cmd/: auto.c cal.c ccd.c cmd_tools.c cmd_tools.h combine.c configure.c crd.c cvd.c cz.c discharge.c effect.c esr.c input.c led.c measure.c ocp.c opp.c power.c resistance.c sequence.c static.c status.c sweep.c system.c transient.c
  group user
    ./: engine.c engine.h gpib.c gpib.h init.c load_register.h main.c socket_app.c socket_app.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h stm32f10x_vector.c uart.c uart.h variable.c variable.h
  group W5500
    w5500/: app_timer.c app_timer.h net_config.c net_config.h socket.c socket.h spix.c spix.h sys_timer.c sys_timer.h w5500.c w5500.h
